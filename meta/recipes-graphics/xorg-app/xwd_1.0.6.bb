require xorg-app-common.inc
DEPENDS += " libxmu "
PR = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=c0cdb783e9a0198237371fdaa26a18bf"

SRC_URI[md5sum] = "6b5d48464c5f366e91efd08b62b12d94"
SRC_URI[sha256sum] = "3bb396a2268d78de4b1c3e5237a85f7849d3434e87b3cd1f4d57eef614227d79"
