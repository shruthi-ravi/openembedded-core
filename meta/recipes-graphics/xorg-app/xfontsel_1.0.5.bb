require xorg-app-common.inc
DESCRIPTION = "point and click selection of X11 font names"
DEPENDS += " libxaw"
PR = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=4669d2703c60d585cc29ba7e9a69bcb3"

SRC_URI[md5sum] = "a40302b88c599b63e3d3d412e02871e6"
SRC_URI[sha256sum] = "170d8550b96fb47b04db6181b947e6f6b8b97f4df5d691c351a278480cc931bf"

