require xorg-app-common.inc
DESCRIPTION = "server font list displayer for X"
PR = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=5ec74dd7ea4d10c4715a7c44f159a40b"

SRC_URI[md5sum] = "5a2b476c2d84759529f01e0cd06145fe"
SRC_URI[sha256sum] = "28179185ec2bf81dfe13652d65bdb2a4ae74e2775df591a62d66a70f80e90cd2"

