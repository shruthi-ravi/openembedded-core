require xorg-app-common.inc
DESCRIPTION = "Sets the visual appearance of the X root window"
DEPENDS += " libxmu xbitmaps"
PR = "1"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ea29dbee22324787c061f039e0529de"

SRC_URI[md5sum] = "7211b31ec70631829ebae9460999aa0b"
SRC_URI[sha256sum] = "ba215daaa78c415fce11b9e58c365d03bb602eaa5ea916578d76861a468cc3d9"

